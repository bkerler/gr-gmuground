options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: delay
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_magphase_0_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '220'
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    comment: |-
      Empirical-based estimation
      for channel synchronization
    delay: int(samp_rate*146e6*111e-6/(145e6))
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wbarnhart/presync/145mhzch1
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/wbarnhart/presync/145mhzch2
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_vector_sink_x_0_0
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 1e3
    decim: '50'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 1500, 500)
    type: ccc
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e2
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 220 Samples for 145 MHz
  states: {}
- name: phase_sync_0
  id: phase_sync
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    label1: Ch1
    label2: Ch2
    label3: Delay and Phase Adjust
    nconnections: '3'
    size: 1024*100
    srate: samp_rate
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    label1: Ch1
    label2: Ch2
    nconnections: '2'
    size: 1024*100
    srate: samp_rate
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}

connections:
- [blocks_complex_to_magphase_0_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_complex_to_magphase_0_0, '1', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_magphase_0_0_0, '0', blocks_vector_sink_x_0_0, '0']
- [blocks_complex_to_magphase_0_0_0, '1', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0, '0', blocks_complex_to_magphase_0_0_0, '0']
- [blocks_delay_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_delay_0_0, '0', blocks_complex_to_magphase_0_0_0, '0']
- [blocks_delay_0_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_delay_0_0_0, '0', phase_sync_0, '0']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_file_source_0_0, '0', low_pass_filter_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_delay_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_magphase_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [low_pass_filter_0, '0', phase_sync_0, '1']
- [low_pass_filter_0_0, '0', blocks_delay_0, '0']
- [low_pass_filter_0_0, '0', blocks_delay_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_delay_0_0_0, '0']
- [phase_sync_0, '0', blocks_complex_to_magphase_0_0_0, '0']
- [phase_sync_0, '0', blocks_complex_to_real_0_0_0, '0']

metadata:
  file_format: 1
